# Keil uVision project rpmsg_lite_pingpong_rtos_cm0plus.uvprojx, settings and files
target rpmsg_lite_pingpong_rtos_cm0plus debug (ARM-ADS)
  device: K32L3A60VPJ1A:cm0plus NXP
  pack: NXP.K32L3A60_DFP.19.0.0
  cpu: CPUTYPE("Cortex-M0+")
  output: rpmsg_lite_pingpong_rtos_cm0plus.out
  AfterMake: fromelf.exe --output "$Lcore1_image.bin" --bincombined "#L"
  c flags: Optim=2 OneElfS=1 v6Lang=3 wLevel=3
  c define: DEBUG, CPU_K32L3A60VPJ1A_cm0plus, MCUXPRESSO_SDK, MULTICORE_APP=1, SDK_OS_FREE_RTOS
  c misc: -fno-common -fdata-sections -fno-builtin -mthumb
  c include: board;source;CMSIS;component/lists;component/uart;device;drivers;frdmk32l3a6/multicore_examples/rpmsg_lite_pingpong_rtos/cm0plus;freertos/freertos-kernel/include;freertos/freertos-kernel/portable/GCC/ARM_CM0;mcmgr;rpmsg_lite/include;rpmsg_lite/include/environment/freertos;rpmsg_lite/include/platform/k32l3a6;utilities
  asm define: DEBUG
  asm include: source;freertos/freertos-kernel/include
  library: MicroLIB
  memory RVCT4: ROM 0x1000000 size 0x40000
  memory RVCT9: RAM 0x9000000 size 0x20000
  scatter file: K32L3A60/arm/K32L3A60xxx_cm0plus_flash.scf
  link misc: --remove --entry=Reset_Handler --diag_suppress 6314 --predefine="-D__use_shmem__=1" --predefine="-D__stack_size__=0x400"
--remove
  group board
    board/: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group CMSIS
    CMSIS/: cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_version.h core_cm0plus.h mpu_armv7.h
  group component/lists
    component/lists/: fsl_component_generic_list.c fsl_component_generic_list.h
  group component/uart
    component/uart/: fsl_adapter_lpuart.c fsl_adapter_uart.h
  group device
    device/: fsl_device_registers.h K32L3A60_cm0plus.h K32L3A60_cm0plus_features.h system_K32L3A60_cm0plus.c system_K32L3A60_cm0plus.h
  group drivers
    drivers/: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_common_arm.c fsl_common_arm.h fsl_gpio.c fsl_gpio.h fsl_lpuart.c fsl_lpuart.h fsl_msmc.c fsl_msmc.h fsl_mu.c fsl_mu.h fsl_port.h
  group freertos/freertos-kernel
    freertos/freertos-kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos-kernel/include
    freertos/freertos-kernel/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h freertos_tasks_c_additions.h list.h message_buffer.h mpu_prototypes.h mpu_syscall_numbers.h mpu_wrappers.h newlib-freertos.h picolibc-freertos.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
  group freertos/freertos-kernel/portable/GCC/ARM_CM0
    freertos/freertos-kernel/portable/GCC/ARM_CM0/: port.c portmacro.h
  group freertos/freertos-kernel/portable/MemMang
    freertos/freertos-kernel/portable/MemMang/: heap_4.c
  group freertos/freertos-kernel/portable
    freertos/freertos-kernel/portable/: readme.txt
  group mcmgr/doc
    mcmgr/doc/: all_0.html all_1.html all_2.html dir_68267d1309a1af8e8297ef4c3efbcdba.html enums_0.html enums_1.html enumvalues_0.html functions_0.html group__mcmgr.html groups_0.html index.html mcmgr_8h_source.html modules.html nomatches.html pages_0.html typedefs_0.html
  group mcmgr
    mcmgr/: mcmgr.c mcmgr.h mcmgr_internal_core_api.h mcmgr_internal_core_api_k32l3a6.c mcmgr_mu_internal.c readme.txt
  group rpmsg_lite/common
    rpmsg_lite/common/: llist.c
  group rpmsg_lite/doc
    rpmsg_lite/doc/: all_0.html all_1.html all_2.html all_3.html all_4.html all_5.html all_6.html all_7.html all_8.html all_9.html all_a.html classes_0.html dir_5a30104352ef4255dc24354b02eb2d20.html dir_97aefd0d527b934f1d99a682da8fe6a9.html files_0.html functions_0.html group__config.html group__rpmsg__lite.html group__rpmsg__ns.html group__rpmsg__queue.html groups_0.html index.html modules.html nomatches.html pages_0.html rpmsg__default__config_8h.html rpmsg__default__config_8h_source.html rpmsg__lite_8h_source.html rpmsg__ns_8h_source.html rpmsg__queue_8h_source.html typedefs_0.html variables_0.html variables_1.html variables_2.html variables_3.html variables_4.html variables_5.html variables_6.html variables_7.html variables_8.html variables_9.html variables_a.html
  group rpmsg_lite/include/environment/freertos
    rpmsg_lite/include/environment/freertos/: rpmsg_env_specific.h
  group rpmsg_lite/include
    rpmsg_lite/include/: llist.h rpmsg_compiler.h rpmsg_default_config.h rpmsg_env.h rpmsg_lite.h rpmsg_ns.h rpmsg_queue.h virtio_ring.h virtqueue.h
  group rpmsg_lite/include/platform/k32l3a6
    rpmsg_lite/include/platform/k32l3a6/: rpmsg_platform.h
  group rpmsg_lite
    rpmsg_lite/: readme.txt
  group rpmsg_lite/rpmsg_lite/porting/environment
    rpmsg_lite/rpmsg_lite/porting/environment/: rpmsg_env_freertos.c
  group rpmsg_lite/rpmsg_lite/porting/platform/k32l3a6
    rpmsg_lite/rpmsg_lite/porting/platform/k32l3a6/: rpmsg_platform.c
  group rpmsg_lite/rpmsg_lite
    rpmsg_lite/rpmsg_lite/: rpmsg_lite.c rpmsg_ns.c rpmsg_queue.c
  group rpmsg_lite/virtio
    rpmsg_lite/virtio/: virtqueue.c
  group source
    source/: FreeRTOSConfig.h main_remote.c rpmsg_config.h
  group startup
    startup/: startup_K32L3A60_cm0plus.S
  group utilities
    utilities/: fsl_assert.c fsl_assert.h fsl_debug_console.c fsl_debug_console.h fsl_str.c fsl_str.h
target rpmsg_lite_pingpong_rtos_cm0plus release (ARM-ADS)
  device: K32L3A60VPJ1A:cm0plus NXP
  pack: NXP.K32L3A60_DFP.19.0.0
  cpu: CPUTYPE("Cortex-M0+")
  output: rpmsg_lite_pingpong_rtos_cm0plus.out
  AfterMake: fromelf.exe --output "$Lcore1_image.bin" --bincombined "#L"
  c flags: Optim=7 OneElfS=1 v6Lang=3 wLevel=3
  c define: NDEBUG, CPU_K32L3A60VPJ1A_cm0plus, MCUXPRESSO_SDK, MULTICORE_APP=1, SDK_OS_FREE_RTOS
  c misc: -fno-common -fdata-sections -fno-builtin -mthumb
  c include: as above
  asm define: NDEBUG
  asm include: source;freertos/freertos-kernel/include
  library: MicroLIB
  memory RVCT4: ROM 0x1000000 size 0x40000
  memory RVCT9: RAM 0x9000000 size 0x20000
  scatter file: K32L3A60/arm/K32L3A60xxx_cm0plus_flash.scf
  link misc: as above
